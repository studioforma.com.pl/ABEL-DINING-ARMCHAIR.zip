Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Abel-dining chair - ver4.ifc
Time: 2022-12-28T13:47:18
Author: utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (9)
Name
 | Componente#2 - Description: Componente#2; ObjectType: SketchupComponentInstance
 | Componente#3 - Description: Componente#3; ObjectType: SketchupComponentInstance
 | Componente#4 - Description: Componente#4; ObjectType: SketchupComponentInstance
 | Componente#1 - Description: Componente#1; ObjectType: SketchupComponentInstance
 | Componente#8 - Description: Componente#8; ObjectType: SketchupComponentInstance
 | Componente#5 - Description: Componente#5; ObjectType: SketchupComponentInstance
 | Componente#6 - Description: Componente#6; ObjectType: SketchupComponentInstance
 | Componente#7 - Description: Componente#7; ObjectType: SketchupComponentInstance
 | Componente#9 - Description: Componente#9; ObjectType: SketchupComponentInstance
